# Keil uVision project NUC140_Code.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.2
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Nuvoton\NUC140BSP\CMSIS\CM0\CoreSupport;..\Nuvoton\NUC140BSP\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\Nuvoton\NUC140BSP\NuvotonPlatform_Keil\Include;..\Nuvoton\NUC140BSP\NuvotonPlatform_Keil\Include\Driver;..\Nuvoton\NUC140BSP\NuvotonPlatform_Keil\Include\NUC1xx-LB_002;.\;..\Source_Code
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Nuvoton/NUC140BSP/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../Nuvoton/NUC140BSP/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../Nuvoton/NUC140BSP/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group USer
    ./: main.c NUC_config.c NUC_config.h
  group Library
    ../Nuvoton/NUC140BSP/NuvotonPlatform_Keil/Src/Driver/: DrvGPIO.c DrvUART.c DrvSYS.c DrvTIMER.c
